# Keil uVision project libStdDriver.uvprojx, settings and files
target libstddriver-rtp (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: libstddriver_keil +hex (library)
  AfterMake: xcopy /y ".\build\keil5\@L.lib" "."
  c flags: Optim=3 OneElfS=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_MA35D1_SUBM
  c include: ..\inc;..\..\CMSIS\Include;..\..\Device\Nuvoton\MA35D1\Include;.
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\linking_scripts\m2354_flash.sct
  link misc: --map --first='startup_M2354.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group src
    ../src/: nu_adc.c nu_canfd.c nu_ccap.c nu_clk.c nu_disp.c nu_eadc.c nu_ebi.c nu_ecap.c nu_epwm.c nu_gpio.c nu_i2c.c nu_i2s.c nu_kpi.c nu_pdma.c nu_qei.c nu_qspi.c nu_rtc.c nu_sc.c nu_scuart.c nu_sdh.c nu_spi.c nu_ssmcc.c nu_sspcc.c nu_sys.c nu_timer.c nu_timer_pwm.c nu_uart.c nu_wdt.c nu_whc.c nu_wwdt.c
